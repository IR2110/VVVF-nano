# Repository IR2110/VVVF-nano

## KiCad design Kicad/VVVF_nano_v2/VVVF_nano_v2.kicad_pcb

Parts:
C1, C7, C8, C9, C11: 0.1uF; C_0603_1608Metric
C2, C3, C4, C5, C10: 10uF; C_0805_2012Metric
C6: 1uF; C_0603_1608Metric
D1: LED_red; LED_0603_1608Metric
D2, D4: SS14; D_SMA
D3: LED_white; LED_0603_1608Metric; JLCPCB C2290
J1: USB_C_16P; USB_C_Receptacle_G-Switch_GT-USB-7010ASV; LCSC C2765186
J2: Conn_02x05_Counter_Clockwise; IDC-Header_2x05_P2.54mm_Vertical
J3, J4: Conn_01x16_Socket; PinSocket_1x16_P2.54mm_Vertical
JP1, JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
LS1: 8Ohm; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R3, R9, R10, R11: 5.1k; R_0603_1608Metric
R4, R5, R6, R7, R12: 10k; R_0603_1608Metric
R8: 1.5k; R_0603_1608Metric
SW1, SW2, SW3, SW4: SW_Push; SW_SPST_TS-1088-xR020
TP1: TestPoint
U1: 74LVC2G14GW,125; SOT-363_SC-70-6
U2: LDL1117S33R; SOT-223-3_TabPin2
U3: MC34119DRG; SOP-8_3.76x4.96mm_P1.27mm; LCSC Part C5145246
U4: ESP32-S3-WROOM-1-N16R8; ESP32-S3-WROOM-1

Connections:
+3.3V: C1.1, C4.2, C9.1, J3.15, J4.15, R1.2, R9.1, R10.1, U1.5 (VCC), U2.2 (OUT), U4.2 (3V3)
+5V: C2.2, C8.1, D2.1 (K), D4.1 (K), U2.3 (IN), U3.6 (Vcc)
/3LVL_OK: J4.1, JP1.2 (B), U4.20 (IO12)
/D+: J1.A6 (D+), J1.B6 (D+), U4.14 (USB_D+)
/D-: J1.A7 (D-), J1.B7 (D-), U4.13 (USB_D-)
/Enable: J3.11, JP2.2 (B), R11.2, R12.2, U4.7 (IO7)
/IO1: J4.14, U4.39 (IO1)
/IO2: J4.13, U4.38 (IO2)
/IO3: J3.5, U4.15 (IO3)
/IO4: J2.1, J3.14, U1.1, U4.4 (IO4)
/IO5: J2.3, J3.13, R6.1, U4.5 (IO5)
/IO6: J2.5, J3.12, U4.6 (IO6)
/IO8: J3.6, U4.12 (IO8)
/IO9: J2.6, J3.3, U1.3, U4.17 (IO9)
/IO10: J2.4, J3.2, R7.1, U4.18 (IO10)
/IO11: J2.2, J3.1, U4.19 (IO11)
/IO13: J4.2, SW1.2, U4.21 (IO13)
/IO14: J4.3, SW2.2, U4.22 (IO14)
/IO15: J3.10, U4.8 (IO15)
/IO16: J3.9, U4.9 (IO16)
/IO17: J3.8, U4.10 (IO17)
/IO18: J3.7, U4.11 (IO18)
/IO21: J4.4, U4.23 (IO21)
/IO38: J4.8, U4.31 (IO38)
/IO39: J4.9, U4.32 (IO39)
/IO40: J4.10, U4.33 (IO40)
/IO41: J4.11, U4.34 (IO41)
/IO42: J4.12, U4.35 (IO42)
/IO45: J4.7, U4.26 (IO45)
/IO46: J3.4, U4.16 (IO46)
/IO47: J4.5, U4.24 (IO47)
/IO48: J4.6, U4.25 (IO48)
GND: C1.2, C2.1, C3.2, C4.1, C6.2, C7.2, C8.2, C9.2, C11.2, D1.1 (K), D3.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.9, J3.16, J4.16, R2.2, R3.2, R12.1, SW1.1, SW2.1, SW3.1, SW4.1, U1.2 (GND), U2.1 (ADJ/GND), U3.1 (CD), U3.7 (GND), U4.1 (GND), U4.40 (GND), U4.41 (GND)
unnamed: C5.2, C10.2, R4.2, R5.2, R6.2, R7.2, TP1.1
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: D3.2 (A), R11.1
unnamed: D4.2 (A), J2.10
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R3.1
unnamed: J2.7, JP2.1 (A)
unnamed: J2.8, JP1.1 (A)
unnamed: R4.1, U1.6
unnamed: R5.1, U1.4
unnamed: C6.1, U3.3 (FC1/Vin+)
unnamed: C3.1, U3.2 (FC2)
unnamed: C5.1, C10.1, R8.1, U3.4 (Vin-)
unnamed: LS1.2, R8.2, U3.5 (Vo1)
unnamed: LS1.1, U3.8 (Vo2)
unnamed: C7.1, R9.2, SW3.2, U4.3 (EN)
unnamed: C11.1, R10.2, SW4.2, U4.27 (IO0)

Notes on the sheet:
High(3.3V)のとき3レベル出力可能と判断。

Board: 2 copper layers, 31.8 x 55.9 mm, 42 parts (2 on the bottom side), 51 nets.
